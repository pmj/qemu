## hw/vmapple/Kconfig
```kconfig
config VMAPPLE_AES
    bool

config VMAPPLE_BDIF
    bool

config VMAPPLE_PVG
    bool
```
